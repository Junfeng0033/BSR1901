# Keil uVision project bsr1901_demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: bsr1901_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --locale=english
  c include: .\include;.\bms\ip2366;.\tft_lcd;.\user;.\SCGUI;.\SCGUI\example;.\SCGUI\touch_lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\scatter_bsr1901_demo.sct
  group startup
    ./startup/: startup_cm0.s system_initial.c
  group peripheral
    ./peripheral/: aon.c cmu.c iomux.c isr.c uart.c gpio.c gpio_i2c.c adc.c spi.c spi2ahb.c timer.c systick.c pwm.c watchdog.c dma.c efuse.c opa.c mos.c charger.c
  group bms
    ./bms/ip2366/: bms_ip2366.c
  group norflash
    ./norflash/xtxflash/: dpi_common.c xt25f32.c
  group tft_lcd
    ./tft_lcd/: lcd_driver.c
  group scgui
    ./: SCGUI GUIDE.md
    ./SCGUI/: sc_arc.c sc_common.c sc_compose.c sc_event_task.c sc_gui.c sc_keyboard.c sc_lvgl_font.c sc_menu.c sc_transform.c
  group scgui/font
    ./SCGUI/font/: lv_font_12.c lv_font_16.c lv_font_20.c
  group scgui/bmp
    ./SCGUI/bmp/: bashen.c test_img.c watch_106_64.c
  group user
    ./user/: main.c img_cake_32b.c img_star_32b.c key_process.c img_cake.c img_star.c img_battery.c img_battery_32b.c fire_eye_img.c ui_circle_100x100.c ui.c GUI.c font_0_9_digital_32b.c font_A_z_32b.c
    ./user/ui_img/: charging.c charging_32bit.c
    ./SCGUI/example/: sc_demo_test.c
